<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>freq</value></param>
<param><key>value</key><value>1500000000</value></param>
<param><key>min</key><value>390000000</value></param>
<param><key>max</key><value>2500000000</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>int_converter</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>gain</value></param>
<param><key>value</key><value>10000</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>50000</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>int_converter</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>analog_wfm_tx</key>
<param><key>id</key><value>analog_wfm_tx_0</value></param>
<param><key>audio_rate</key><value>samp_rate</value></param>
<param><key>quad_rate</key><value>samp_rate*4</value></param>
<param><key>tau</key><value>75e-6</value></param>
<param><key>max_dev</key><value>75e3</value></param>
</block>
<block>
<key>fractional_resampler_xx</key>
<param><key>id</key><value>fractional_resampler_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>phase_shift</key><value>1</value></param>
<param><key>resamp_ratio</key><value>0.875</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
<param><key>ok_to_block</key><value>False</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>18</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value></value></param>
</block>
<block>
<key>yunsdr_yunsdr_sink</key>
<param><key>id</key><value>yunsdr_yunsdr_sink_0</value></param>
<param><key>ipaddr</key><value>192.168.1.10</value></param>
<param><key>port</key><value>5004</value></param>
<param><key>tx_freq</key><value>freq</value></param>
<param><key>tx_vga</key><value>gain</value></param>
<param><key>sample_rate</key><value>4000000</value></param>
<param><key>nchan</key><value>1</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>1500000000</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>4e6</value></param>
</block>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>yunsdr_yunsdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fractional_resampler_xx_0</source_block_id><sink_block_id>analog_wfm_tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_wfm_tx_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>fractional_resampler_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
